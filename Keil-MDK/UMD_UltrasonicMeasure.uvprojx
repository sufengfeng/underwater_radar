# Keil uVision project UMD_UltrasonicMeasure.uvprojx, settings and files
target DYSTM32F4_V1.2超声测距_CODE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UMD_UltrasonicMeasure +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1
  c include: ..\Std_Lib\Libraries\CMSIS\DSP_Lib;..\Std_Lib\Libraries\CMSIS\ST_Device;..\Std_Lib\Libraries\inc;..\Periph;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: Main.c stm32f4xx_it.c Correlation.c Communication.c FIR.c
  group Periph
    ../Periph/: PortConfig.c Delay.c Sys.c DAC.c ADC.c TIM.c UART.c Stack.c LCD12864.c
  group Std_PeriphLib
    ../Std_Lib/Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Std_DSPLib
    ../Std_Lib/Libraries/CMSIS/DSP_Lib/: arm_cortexM4lf_math.lib
  group StartFile
    ../Std_Lib/Libraries/CMSIS/ST_Device/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Std_Lib/Libraries/CMSIS/ST_Device/: system_stm32f4xx.c
  group Readme
    ../: Readme.txt
software components: CMSIS:CORE 5.0.0
